# Keil uVision project ESurfingOS.uvprojx, settings and files
target CTIOT_MQTT (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ctiot_mqtt_target
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32F429xx NDEBUG MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h> WITH_LWIP LWIP_DEBUG WITH_MQTT ATINY_DEBUG WITH_CTIOT_DEMO
  c misc: --diag_suppress=1,47,177,186,223,1294,1295
  c include: ..\Inc;..\..\..\include\osdepends\liteos;..\OS_CONFIG;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\components\security\mbedtls\mbedtls_port;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\include;..\..\..\include\ctiot_mqtt;..\Hardware\Inc;..\..\..\demos;..\..\..\demos\ctiot_mqtt;..\..\..\kernel\include;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\common\cmsis;..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\components\net\lwip\lwip_port;..\..\..\components\net\lwip\lwip_port\OS;..\..\..\osdepends\liteos\cmsis;..\..\..\components\lib\cJSON;..\..\..\components\connectivity\mqtt\MQTTPacket\src;..\..\..\components\connectivity\mqtt\MQTTClient-C\src;..\..\..\components\connectivity\mqtt\MQTTClient-C\src\liteOS;..\..\..\components\connectivity\ctiot\ctiot_mqtt;..\..\..\components\net\lwip\lwip-2.0.3\src\include\lwip\prot;..\..\..\components\net\lwip\lwip-2.0.3\src\include\lwip
  asm misc: --diag_suppress=A1581W
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F429IGTx-LiteOS.sct
  group ctiot_demo
    ../../../demos/ctiot_mqtt/: ctiot_mqtt_demo.c ctiot_mqtt_demo.h ctiot_device_info.h
  group user
    ../Src/: system_stm32f4xx.c dwt.c sys_init.c main.c user_task.c
  group log
    ../../../components/log/: atiny_log.c
  group CJSON
    ../../../components/lib/cJSON/: cJSON.c cJSON.h
  group MQTT_PAHOO
    ../../../components/connectivity/mqtt/MQTTClient-C/src/: MQTTClient.c
    ../../../components/connectivity/mqtt/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group MQTT_client
    ../../../components/connectivity/mqtt/MQTTClient-C/src/liteOS/: MQTTliteos.c MQTTliteos.h
    ../../../components/connectivity/ctiot/ctiot_mqtt/: ctiot_mqtt_client.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group atiny_dep
    ../../../components/lib/libc/: malloc.c errno.c
    ../../../components/net/sal/: atiny_socket.c
  group LWIP_src
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c
  group LWIP_port
    ../Src/: eth.c
    ../../../components/net/lwip/lwip_port/OS/: ethernetif.c sys_arch.c
  group os_depends
    ../../../osdepends/liteos/: atiny_osdep.c
  group LITE-OS/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group LITE-OS/arch
    ../Src/: usart.c
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group LITE-OS/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group Driver
    ../Hardware/Src/: hal_flash.c hal_iwdg.c hal_rng.c hal_spi_flash.c
  group STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_eth.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_iwdg.c
  group startup
    ./: los_startup_keil.s
software components: CMSIS:CORE 5.0.1
